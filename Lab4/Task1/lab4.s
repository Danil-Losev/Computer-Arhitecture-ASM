;Losev Danil EPI-4-23 lab 4 task 1

	AREA MYCODE, CODE, READONLY
	ENTRY
	MOV R0, #0
	LDR R1, POINTER
	LDR R2, N
	BL LOOP
	B STOP


LOOP
	LDR R3, [R1], #4
	
	CMP R3, #5
	BGT ADDNUM
	
	SUBS R2, R2, #1
	BGT LOOP
	
	LDR R4, SUMP
	STR R0, [R4]
	BX LR

ADDNUM
	ADD R0, R0, R3 
	SUBS R2, R2, #1
	BGT LOOP
	
	LDR R4, SUMP
	STR R0, [R4]
	BX LR

STOP B STOP

	AREA MYCODE, CODE, READWRITE
SUM		DCD		0
SUMP 	DCD 	SUM
N 		DCD 	7
NUM1 	DCD 	3, -7, 2, -2, 10, 20, 30
POINTER DCD 	NUM1

	END